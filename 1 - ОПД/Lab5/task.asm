	ORG	0x47E
BEGIN:	WORD	0x62b
CUR:	WORD	?
FIRST:	WORD	?
SECOND:	WORD	?
COUNTERN:	WORD	?
CONST:	WORD	0x8	
BUF:	WORD	?
START:	CLA	
	 LD	BEGIN
	 ST	CUR
	LD 	CONST
	ST	BUF
	LD	(CUR)+
CIKL:	ASL	
	LOOP	BUF
	JUMP	CIKL
	SWAB	
	ST	COUNTERN
L0:	IN	7
	AND	#0x40
	BEQ	L0
	LD	COUNTERN
	OUT	6
	BEQ	STOP
S0:	LD	(CUR)+
	ST	FIRST
	SWAB	
	ST	SECOND
L1:	IN	7
	AND	#0x40
	BEQ	L1
	LD	FIRST
	OUT	6
	LD	COUNTERN
	DEC	
	BEQ	STOP
	ST	COUNTERN
L2:	IN	7
	AND	#0x40
	BEQ	L2
	LD	SECOND
	OUT	6
	LD	COUNTERN
	DEC	
	BEQ	STOP
	ST	COUNTERN
	JUMP	S0
STOP: 	HLT  	
		
	ORG	0x62b
	WORD	0x0004
	WORD	0xBBBA
	WORD	0xBDB5
