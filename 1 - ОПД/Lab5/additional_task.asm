; Доп:
  ; С клавиатуры вводится текст в любой кодировке(на выбор), текст завершается по нажатию ENTER
  ; Необходимо вывести на принтер коды введеных нами ранее символов 





	ORG	0x3D1
		
N0:	WORD	0x0000
N1:	WORD	0x0001
N2:	WORD	0x0002
N3:	WORD	0x0003
N4:	WORD	0x0004
N5:	WORD	0x0005
N6:	WORD	0x0006
N7:	WORD	0x0007
N8:	WORD	0x0008
N9:	WORD	0x0009
NA:	WORD	0x000A
NB:	WORD	0x000B
NC:	WORD	0x000C
ND:	WORD	0x000D
NE:	WORD	0x000E
NF:	WORD	0x000F
		
AN0:	WORD	0x0030
AN1:	WORD	0x0031
AN2:	WORD	0x0032
AN3:	WORD	0x0033
AN4:	WORD	0x0034
AN5:	WORD	0x0035
AN6:	WORD	0x0036
AN7:	WORD	0x0037
AN8:	WORD	0x0038
AN9:	WORD	0x0039
ANA:	WORD	0x0041
ANB:	WORD	0x0042
ANC:	WORD	0x0043
ANDD:	WORD	0x0044
ANE:	WORD	0x0045
ANF:	WORD	0x0046
		
		
BEGIN:	WORD	0x4D1
CURSAVE:	WORD	?
RETSAVE:	WORD	?
TEMP:	WORD	?
FINISH:	WORD	0x000A
FIRST:	WORD	?
SECOND:	WORD	?
COUNT:	WORD	?
PROBEL:	WORD	0x0020
START:	CLA	
	LD	BEGIN
	ST	CURSAVE
	ST	RETSAVE
S1:	IN	0x019
	AND	#0x40
	BEQ	S1
	IN	0x018
	ST	TEMP
	CMP	FINISH
	BEQ	STOP
RAZDEL:	ASR	
	ASR	
	ASR	
	ASR	
	ST	FIRST
	LD	TEMP
	SWAB	
	ASL	
	ASL	
	ASL	
	ASL	
	SWAB	
	ASR	
	ASR	
	ASR	
	ASR	
	ST	SECOND
	LD	FIRST
	CALL	PROVERKA
	ST	(CURSAVE)+
	LD	SECOND
	CALL	PROVERKA
	ST	(CURSAVE)+
	LD	COUNT
	INC	
	ST	COUNT
	JUMP	S1
		
STOP:  	LD	(RETSAVE)+
	OUT	0x0C
	LD	(RETSAVE)+
	OUT	0x0C
	LD	PROBEL
	OUT	0x0C
	LOOP	COUNT
	JUMP	STOP
	HLT	
		
PROVERKA:	CMP	N0
	BEQ	G0
	CMP	N1
	BEQ	G1
	CMP	N2
	BEQ	G2
	CMP	N3
	BEQ	G3
	CMP	N4
	BEQ	G4
	CMP	N5
	BEQ	G5
	CMP	N6
	BEQ	G6
	CMP	N7
	BEQ	G7
	CMP	N8
	BEQ	G8
	CMP	N9
	BEQ	G9
	CMP	NA
	BEQ	GA
	CMP	NB
	BEQ	GB
	CMP	NC
	BEQ	GC
	CMP	ND
	BEQ	GD
	CMP	NE
	BEQ	GE
	CMP	NF
	BEQ	GF
		
G0:	LD	AN0
	RET	
G1:	LD	AN1
	RET	
G2:	LD	AN2
	RET	
G3:	LD	AN3
	RET	
G4:	LD	AN4
	RET	
G5:	LD	AN5
	RET	
G6:	LD	AN6
	RET	
G7:	LD	AN7
	RET	
G8:	LD	AN8
	RET	
G9:	LD	AN9
	RET	
GA:	LD	ANA
	RET	
GB:	LD	ANB
	RET	
GC:	LD	ANC
	RET	
GD:	LD	ANDD
	RET	
GE:	LD	ANE
	RET	
GF:	LD	ANF
	RET	
